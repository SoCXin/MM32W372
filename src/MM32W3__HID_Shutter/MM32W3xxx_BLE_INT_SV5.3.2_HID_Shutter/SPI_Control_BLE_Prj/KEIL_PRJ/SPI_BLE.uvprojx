# Keil uVision project SPI_BLE.uvprojx, settings and files
target MM32W3xx_HID_Shutter (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F103RBT MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ManleyDK103 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER DEVICE_INFO_SUPPORT USE_UART BLE_PAIR_SUPPORT
  c include: ..\..\Device\CMSIS\KEIL_CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\HARDWARE\SPI;..\HARDWARE\RF_IRQ;..\HARDWARE\RF_Callback;..\SRC_LIB\inc;..\HARDWARE\PWR_Control;..\..\Device\MM32W3xxB\HAL_lib\inc;..\..\Device\MM32W3xxB\Include;..\HARDWARE\IWDG;..\HARDWARE\AT_CMD;..\..\Device\MM32W3xx\HAL_lib\inc;..\..\Device\MM32W3xx\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c
  group STARTUP
    ../../Device/MM32W3xx/Source/: system_MM32W3xx.c
    ../../Device/MM32W3xx/Source/KEIL_StartAsm/: startup_MM32W3xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group HARDWARE
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/RF_IRQ/: RF_IRQ.c
    ../HARDWARE/PWR_Control/: PWR_Control.c
    ../HARDWARE/RF_Callback/: RF_Callback.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/AT_CMD/: AT_CMD.c
  group SRC_RF
    ../SRC_LIB/: app_hogp.c
    ../SRC_LIB/lib/: mg_BLEpair_lib_m3.lib mg_TEST_Lib.lib
  group HALlib
    ../../Device/MM32W3xx/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group README
    ../../: README.txt ChangeList.txt
